# Keil uVision project Demo.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: Demo
  group Source Group 1
    ./: main (2).c main (3).c main (4).c main (5).c main (6).c main (7).c main (8).c main (9).c main.c
  group need
    ./Listings/: adc.lst BEEP.lst BEEP.map BEEP2.lst Bluetooth.lst Bluetooth.map delay.lst delay2.lst delay3.lst delay4.lst delay5.lst delay6.lst delay7.lst HC_SR04.map HW.map hw2.lst KEY.map LED.lst LED.map LED2.lst main.lst main2.lst main3.lst main4.lst main5.lst main6.lst main7.lst main8.lst main9.lst motor.lst motor3.lst motor4.lst motor5.lst motor6.lst PWM.map sr04.lst sr05.lst Test.map time3r.lst timer.lst timer2.lst timer4.lst timer5.lst timer6.lst uart1.lst Uart1_Send_Adc.map uart2.lst uart3.lst uart4.lst uart5.lst uart6.lst
    ./HARDWARE/src/: adc.c BEEP (2).c BEEP.c Bluetooth.c delay (2).c delay (3).c delay (4).c delay (5).c delay (6).c delay (7).c delay.c hw.c LED (2).c LED.c motor (2).c motor (3).c motor (4).c motor (5).c motor.c sr04 (2).c sr04.c timer (2).c timer (3).c timer (4).c timer (5).c timer.c uart1 (2).c uart1 (3).c uart1 (4).c uart1.c uart2.c
    ./HARDWARE/inc/: adc.h BEEP (2).h BEEP.h Bluetooth.h delay (2).h delay (3).h delay (4).h delay (5).h delay (6).h delay (7).h delay.h hw.h LED (2).h LED.h motor (2).h motor (3).h motor (4).h motor (5).h motor.h sr04 (2).h sr04.h timer (2).h timer (3).h timer (4).h timer (5).h timer.h uart1 (2).h uart1 (3).h uart1 (4).h uart1.h uart2.h
    ./Objects/: adc.__i adc.crf adc.obj BEEP BEEP (2).crf BEEP (2).obj BEEP.__i BEEP.build_log.htm BEEP.crf BEEP.hex BEEP.lnp BEEP.obj Bluetooth Bluetooth.build_log.htm Bluetooth.crf Bluetooth.hex Bluetooth.lnp Bluetooth.obj delay (2).crf delay (2).obj delay (3).crf delay (3).obj delay (4).crf delay (4).obj delay (5).crf delay (5).obj delay (6).crf delay (6).obj delay (7).crf delay (7).obj delay.crf delay.obj Demo.build_log.htm HC_SR04 HC_SR04.build_log.htm HC_SR04.hex HC_SR04.lnp HW hw.__i HW.build_log.htm hw.crf HW.hex HW.lnp hw.obj KEY KEY.build_log.htm KEY.hex KEY.lnp LED LED (2).crf LED (2).obj LED.__i LED.build_log.htm LED.crf LED.hex LED.lnp LED.obj main (2).crf main (2).obj main (3).crf main (3).obj main (4).crf main (4).obj main (5).crf main (5).obj main (6).crf main (6).obj main (7).crf main (7).obj main (8).crf main (8).obj main (9).crf main (9).obj main.crf main.obj motor (2).__i motor (2).crf motor (2).obj motor (3).__i motor (3).crf motor (3).obj motor (4).crf motor (4).obj motor (5).crf motor (5).obj motor.__i motor.crf motor.obj PWM PWM.build_log.htm PWM.hex PWM.lnp sr04 (2).__i sr04 (2).crf sr04 (2).obj sr04.__i sr04.crf sr04.obj Test Test.build_log.htm Test.hex Test.lnp timer (2).__i timer (2).crf timer (2).obj timer (3).__i timer (3).crf timer (3).obj timer (4).crf timer (4).obj timer (5).crf timer (5).obj timer (6).crf timer (6).obj timer.__i timer.crf timer.obj uart1 (2).crf uart1 (2).obj uart1 (3).crf uart1 (3).obj uart1 (4).crf uart1 (4).obj uart1 (5).crf uart1 (5).obj uart1.__i uart1.crf uart1.obj Uart1_Send_Adc Uart1_Send_Adc.build_log.htm Uart1_Send_Adc.hex Uart1_Send_Adc.lnp uart2.crf uart2.obj
