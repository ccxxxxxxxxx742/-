#include "BEEP.h"    
#include "delay.h" 

sbit BEEP=P3^6;		//重定义蜂鸣器引脚功能   

unsigned char Timer0_TH0 = 0;
unsigned char Timer0_TL0 = 0;
unsigned char Time = 0;
/*********************************************************************
* “小星星” 乐谱
**********************************************************************/   
 unsigned char Music[]={

1,2,2, 1,2,2, 5,2,2, 5,2,2, 6,2,2, 6,2,2, 5,2,4,

4,2,2, 4,2,2, 3,2,2, 3,2,2, 2,2,2, 2,2,2, 1,2,4,

5,2,2, 5,2,2, 4,2,2, 4,2,2, 3,2,2, 3,2,2, 2,2,4,

5,2,2, 5,2,2, 4,2,2, 4,2,2, 3,2,2, 3,2,2, 2,2,4,

1,2,2, 1,2,2, 5,2,2, 5,2,2, 6,2,2, 6,2,2, 5,2,4,

4,2,2, 4,2,2, 3,2,2, 3,2,2, 2,2,2, 2,2,2, 1,2,4 };
/*********************************************************************
* 高音
**********************************************************************/  
 unsigned char HighFrequency[]={

0xF2,0xF3,0xF5,0xF5,0xF6,0xF7,0xF8,

0xF9,0xF9,0xFA,0xFA,0xFB,0xFB,0xFC,

0xFC,0xFC,0xFD,0xFD,0xFD,0xFD,0xFE,

0xFE,0xFE,0xFE,0xFE,0xFE,0xFE,0xFF,};
/*********************************************************************
* 低音
**********************************************************************/  
 unsigned char LowFrequency[]={

0x42,0xC1,0x17,0xB6,0xD0,0xD1,0xB6,

0x21,0xE1,0x8C,0xD8,0x68,0xE9,0x5B,

0x8F,0xEE,0x44, 0x6B,0xB4,0xF4,0x2D,

0x47,0x77,0xA2,0xB6,0xDA,0xFA,0x16,}; 
 
/********************************************************************** 
函 数 名：Delay_Music(unsigned char Time)
功    能：节拍延时函数
说    明：调1/4 310ms 调2/4  250ms 调3/4  187ms 调4/4  125ms 
参    数: Time:延时时间
返 回 值：无   
***********************************************************************/
void Delay_Music(unsigned char Time)
{
    unsigned char i = 0;
		for(i = 0;i < Time;i ++)
		{
			delay_ms(200);
		}
    TR0 = 0;
}
/*****************z`******************************************
功能描述：定时器0初始化  5K /
入口参数：无
返回值：无
************************************************************/
void Timer0Init(void)
{
	TMOD=1; 			//置CT0定时工作方式1
	EA=1;
	ET0=1;				//IE=0x82 //CPU开中断,CT0开中断 		
}
/***********************************************************
功能描述：定时器0中断服务程序
入口参数：无
返回值：无
************************************************************/ 
void timer0_int (void) interrupt 1  
{  
	  TR0 = 0;    	
	  BEEP=!BEEP; 
		TH0 = Timer0_TH0;
	  TL0 = Timer0_TL0;
		TR0 = 1;	 
		TF0 = 0;                 //清除T0中断溢出标志位
}  
/********************************************************************** 
函 数 名：DealMusic(void)
功    能：定时器0溢出中断服务程序
说    明：无
参    数: 无
返 回 值：无   
***********************************************************************/
void DealMusic(void)
{
	TH0 = Timer0_TH0;		//定时器赋值
	TL0 = Timer0_TL0;
	TR0 = 1;       			//开定时器
	Delay_Music(Time); 	//节拍时间                      
} 
/********************************************************************** 
函 数 Play_Music_Happy_Brithday(void)
功    能：定时器0溢出中断服务程序
说    明：无
参    数: 无
返 回 值：无   
***********************************************************************/
void Play_Music_Happy_Brithday(void)
{
	unsigned int i=0,j=0;
	
	while(1) //循环的播放
	{
		  i = 0;  
	   while(i < 126)	 												//音乐数组长度，循环播放
		{        	      
			j = Music[i] + 7 * Music[i + 1] - 1;	//取音乐数据
			Timer0_TH0 = HighFrequency[j];
			Timer0_TL0 = LowFrequency [j];
			Time = Music[i + 2];          				//节拍时长
			i = i + 3;
			DealMusic();
		}
	} 	
}


















